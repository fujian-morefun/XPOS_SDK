# IAR project mf66s.vcprojm66s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEV_MF66S
  ICCARM.CCIncludePath2: ..\..\..\sdk\inc; src; ..\..\..\sdk\inc\aemv\inc; ..\..\..\sdk\inc\AppPub\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LCD_COLOR_1BIT
  OBJCOPY.OOCOutputFile: mf66s_mf66s.bin
  ILINK.IlinkOutputFile: dev.out
  ILINK.IlinkIcfFile: settings\mf66s_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../sdk/lib/mf69r/: pub.a
    ../../../sdk/lib/: AppPub.a apppub2.a atc.a bluetooth.a emvapi.a json.a libapi_xpos.a libqr.a lib_amex.a lib_dpas.a lib_emv.a lib_emvpub.a lib_entry.a lib_paypass.a lib_quics.a lib_rupay.a lib_vcps.a mbedtls.a modem.a mqtt_embed.a net.a png.a polarssl.a power.a productTest.a rpc.a sm.a switchcheck.a tms.a wifi.a xgui.a
    ../../../sdk/driver/lib66s/: FATFS.a FLASH_FAL.a IAR6_crypt_s_lib.a IAR6_MH1903_MSR.a MF66S_HAL.a UCOSII.a
  group src
    src/: main.c sdk_file.c sdk_http.c sdk_pay.c sdk_settings.c sdk_test.c sdk_tts.c sdk_xgui.c test.c
    src/page/: dateTimeInput_page.c
    src/mqttapp/: http_download.c messagearrived.c mqtt_proc.c
    src/mqttapp/pages/: sdk_showqr.c status_page.c
    src/calculator/: calculator.c calculatorpage.c
