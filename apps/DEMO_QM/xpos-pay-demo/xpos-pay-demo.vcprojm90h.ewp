# IAR project xpos-pay-demo.vcprojm90h.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEV_H9
  ICCARM.CCIncludePath2: ..\..\..\sdk\inc; src; ..\..\..\sdk\inc\aemv\inc; ..\..\..\sdk\inc\AppPub\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LCD_COLOR_1BIT
  OBJCOPY.OOCOutputFile: xpos-pay-demo_90h.bin
  ILINK.IlinkOutputFile: dev.out
  ILINK.IlinkIcfFile: settings\90h_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../../sdk/lib/: AppPub.a apppub2.a atc.a bluetooth.a emvapi.a json.a libapi_xpos.a lib_amex.a lib_dpas.a lib_emv.a lib_emvpub.a lib_entry.a lib_paypass.a lib_quics.a lib_rupay.a lib_vcps.a mbedtls.a modem.a net.a polarssl.a power.a productTest.a pub.a rpc.a sm.a switchcheck.a tms.a wifi.a xgui.a
    ../../../sdk/driver/libm90h/: FATFS.a FLASH_FAL.a IAR6_MH1901_MSR_SoftDec_T1T2T3 .a MF60_HAL.a UCOSII.a
  group src
    src/: main.c mpos_func.c mpos_proc.c mpos_pub.c sdk_driver.c sdk_file.c sdk_http.c sdk_img.c sdk_log.c sdk_print.c sdk_security.c sdk_showqr.c sdk_timer.c sdk_xgui.c unknown.c
    src/upay/: upay_barscan.c upay_consum.c upay_print.c upay_pub.c upay_track.c
    src/test/: dateTimeInput.c keySoundSet.c lcdLightSet.c test_pub.c timeTest.c
    src/pages/: inputamount_page.c inputcard_page.c inputNumberString_page.c input_num_page.c input_public.c scan_page.c
